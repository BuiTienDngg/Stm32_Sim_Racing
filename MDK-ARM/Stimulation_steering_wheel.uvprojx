# Keil uVision project Stimulation_steering_wheel.uvprojx, settings and files
target Stimulation_steering_wheel (6230000::V6.23::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x805FFFF)  CLOCK(84000000) FPU2 CPUTYPE("Cortex-M4")
  output: Stimulation_steering_wheel +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/TinyUSB/src
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/Wheel
    ../Core/Src/: wheel.c encoder.c calibration.c usb.c pid.c
  group Middlewares/TinyUSB
    ../Middlewares/Third_Party/TinyUSB/src/: tusb.c
    ../Middlewares/Third_Party/TinyUSB/src/common/: tusb_fifo.c
    ../Middlewares/Third_Party/TinyUSB/src/device/: usbd.c usbd_control.c
    ../Middlewares/Third_Party/TinyUSB/src/class/hid/: hid_device.c
    ../Middlewares/Third_Party/TinyUSB/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
  group Tests/Windows
    ./: wheel_test.py wheel_gui.py wheel_gui.bat ffb_test.py TESTING.md
software components: CMSIS:CORE 4.3.0
